# Repository adafruit/Adafruit-BMP280-Breakout-PCB

File README.md:

## Adafruit BMP280 Breakout PCB

<a href="http://www.adafruit.com/products/2651"><br/>
Click here to purchase one from the Adafruit shop</a>

PCB files for the Adafruit BMP280 Breakout. Format is EagleCAD schematic and board layout
* https://www.adafruit.com/product/2651

### DESCRIPTION
Bosch has stepped up their game with their new BMP280 sensor, an environmental sensor with temperature, barometric pressure that is the next generation upgrade to the BMP085/BMP180/BMP183. This sensor is great for all sorts of weather sensing and can even be used in both I2C and SPI!

This precision sensor from Bosch is the best low-cost, precision sensing solution for measuring barometric pressure with ±1 hPa absolute accuraccy, and temperature with ±1.0°C accuracy. Because pressure changes with altitude, and the pressure measurements are so good, you can also use it as an altimeter with  ±1 meter accuracy.

The BMP280 is the next-generation of sensors from Bosch, and is the upgrade to the BMP085/BMP180/BMP183 - with a low altitude noise of 0.25m and the same fast conversion time. It has the same specifications, but can use either I2C orSPI. For simple easy wiring, go with I2C. If you want to connect a bunch of sensors without worrying about I2C address collisions, go with SPI.

Nice sensor right? So we made it easy for you to get right into your next project. The surface-mount sensor is soldered onto a PCB and comes with a 3.3V regulator and level shifting so you can use it with a 3V or 5V logic microcontroller without worry. We even wrote up a nice tutorial with wiring diagrams, schematics, libraries and examples to get you running in 10 minutes!

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit.com](https://www.adafruit.com)!

Designed by Adafruit Industries.

Creative Commons Attribution, Share-Alike license, check license.txt for more information All text above must be included in any redistribution - see license.txt for more information.

## EAGLE design Adafruit BMP280 STEMMA QT.brd

Parts:
C1: 0.1uF; 0603-NO
C2, C3: 10uF; 0805-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: GREEN; CHIPLED_0603_NOOUTLINE
D2: 1N4148; SOD-323
FID3, FID4: FIDUCIAL_1MM
JP1: HEADER-1X770MIL; 1X07_ROUND_70
Q2: BSS138; SOT363
R1, R4, R5: 10K; 0603-NO
R3: 10K; RESPACK_4X0603
SJ1: SOLDERJUMPER; SOLDERJUMPER_ARROW_NOPASTE
U1: BMP280_COMBO; BMX280_COMBO
U2: AP2112K-3.3; SOT23-5
U$1, U$17: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED

Connections:
3.3V: C1.1, C3.1, JP1.2, Q2.2 (G), Q2.5 (G), R1.1, R3.2 (1), R3.4 (1), R4.2, R5.2, U1.6 (VDDIO), U1.8 (VDD), U2.5 (OUT)
CS: D2.C, JP1.7
CS_3V: D2.A, R5.1, U1.2 (CSB)
GND: C1.2, C2.2, C3.2, CONN3.1 (GND), CONN4.1 (GND), D1.C, JP1.3, SJ1.2, U1.1 (GND), U1.7 (GND), U2.2 (GND)
unnamed: D1.A, R1.2
SCK/SCL: CONN3.4 (SCL), CONN4.4 (SCL), JP1.4, Q2.6 (D), R3.8 (2)
SCK_3V: Q2.1 (S), R3.7 (2), U1.4 (SCK)
SDI/SDA: CONN3.3 (SDA), CONN4.3 (SDA), JP1.6, Q2.3 (D), R3.6 (2)
SDI_3V: Q2.4 (S), R3.5 (2), U1.3 (SDI)
SDO/ADR: JP1.5, R4.1, SJ1.1, U1.5 (SDO)
VCC: C2.1, CONN3.2 (V+), CONN4.2 (V+), JP1.1, R3.1, R3.3 (1), U2.1 (IN), U2.3 (EN)

Notes on the sheet:
I2C Pullups & Shift
STEMMA/I2C Headers
ON LED
Power supply
I2C Pullups

Board: 2 copper layers, 25.4 x 17.8 mm, 24 parts (4 on the bottom side), 11 nets.

Other parts of the board:
U$4: ADAFRUIT_2.5MM
U$25: PCBFEAT-REV-040
U$30, U$31: STEMMAQT

## EAGLE design Adafruit BMP280.brd

Board: 2 copper layers, 17.8 x 19.1 mm, 20 parts (2 on the bottom side), 10 nets.

Parts:
C1, C3: 10uF; 0805-NO
D2: 1N4148; SOD-323
JP2: 1X07_ROUND_70
Q3, Q4: BSS138; SOT23-WIDE
R1, R2, R7, R8: 10K; 0805-NO
R4: 10K; _0805MP
U1: BME280
U2: MIC5225-3.3; SOT23-5
U$2, U$6: ADAFRUIT_2.5MM
U$5, U$15: FIDUCIAL""; FIDUCIAL_1MM
U$7, U$8: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED
U$20: PCBFEAT-REV-040

Connections:
3.3V: C3.1, JP2.2, Q3.1, Q4.1, R1.2, R2.2, R4.2, U1.6, U1.8, U2.5
5.0V: C1.1, JP2.1, R7.2, R8.2, U2.1, U2.3
CS_3V: D2.A, U1.2
CS_5V: D2.C, JP2.7
GND: C1.2, C3.2, JP2.3, U1.1, U1.7, U2.2
SCK/SCL_5V: JP2.4, Q3.3, R7.1
SCK_3V: Q3.2, R2.1, U1.4
SDI/SDA_5V: JP2.6, Q4.3, R8.1
SDI_3V: Q4.2, R1.1, U1.3
SDO/ADR_3V: JP2.5, R4.1, U1.5

## Commit log

2016-09-28 init
2020-07-09 Add updated board files.
2020-07-09 Update image
2020-07-09 Update image.

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
